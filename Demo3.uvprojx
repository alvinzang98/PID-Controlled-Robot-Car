# Keil uVision project Demo3.uvprojx, settings and files
target Demonstration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_Lib\inc;.\MAIN;.\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./MAIN/: init.c main.c WIFI.c USART.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./SYSTEM/: USART.h WIFI.h PID.h init.h pinmap.h
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_StdLib
    ./STM32F10x_Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
